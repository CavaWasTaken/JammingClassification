options:
  parameters:
    author: Arman Ebrahimi Mehr
    copyright: 'NavSAS '
    generate_options: qt_gui
    id: dataset_generation_hack_rf
    output_language: python
    title: Full sample of grabbing signals
  states: {}

blocks:
- name: f_L1
  id: variable
  parameters:
    value: '1575420000'
  states: {}
- name: filename
  id: variable
  parameters:
    value: '''LINKS_L1_10Mhz_complex_float32_'' + time_stamp  + ''_'' + recording_type'
  states: {}
- name: full_filename
  id: variable
  parameters:
    value: os.path.join(root_dir, filename)
  states: {}
- name: recording_type
  id: variable
  parameters:
    value: '''CLEAN'''
  states: {}
- name: root_dir
  id: variable
  parameters:
    value: '''/home/cavallinux/Backup/Magistrale/Navigation-Monitoring/NMon_Dataset_10MHz'''
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '62'
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: time_stamp
  id: variable
  parameters:
    value: datetime.now().strftime('%Y%m%d_%H%M%S')
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: full_filename
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: rx_gain
    bw0: samp_rate
    freq0: f_L1
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '16'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    size: '1024'
    type: float
    xmax: '1'
    xmin: '-1'
  states: {}
- name: qtgui_histogram_sink_x_0_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    size: '1024'
    type: float
    xmax: '1'
    xmin: '-1'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}

connections:
- [blocks_complex_to_float_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_histogram_sink_x_0_0, '0']
- [blocks_correctiq_0, '0', blocks_complex_to_float_0, '0']
- [blocks_correctiq_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_correctiq_0, '0', qtgui_sink_x_0, '0']
- [osmosdr_source_0, '0', blocks_correctiq_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
