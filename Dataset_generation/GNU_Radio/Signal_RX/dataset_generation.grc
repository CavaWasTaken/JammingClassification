options:
  parameters:
    author: Arman Ebrahimi Mehr
    copyright: 'NavSAS '
    generate_options: qt_gui
    id: dataset_generation
    output_language: python
    title: Full sample of grabbing signals
  states: {}

blocks:
- name: IQ_duration
  id: variable
  parameters:
    value: '180'
  states: {}
- name: f_L1
  id: variable
  parameters:
    value: '1575420000'
  states: {}
- name: filename
  id: variable
  parameters:
    value: prefix_filename + '_' + jamming_type + '_' + str(jamming_power)
  states: {}
- name: full_filename
  id: variable
  parameters:
    value: os.path.join(root_dir, jamming_type, filename)
  states: {}
- name: jamming_power
  id: variable
  parameters:
    value: '55'
  states: {}
- name: jamming_type
  id: variable
  parameters:
    value: '''CLEAN'''
  states: {}
- name: prefix_filename
  id: variable
  parameters:
    value: '''LINKS_L1_10Mhz_complex_int8_'' + time_stamp'
  states: {}
- name: root_dir
  id: variable
  parameters:
    value: '''/home/arman-ebrahimi/Downloads/ATLANTIS_Dataset_20MHz'''
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '75'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: time_stamp
  id: variable
  parameters:
    value: datetime.now().strftime('%Y%m%d_%H%M%S')
  states: {}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: 2**7
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: 2**15
    vector_output: 'False'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/n-smart-system/Downloads/NavSAS_L1_5MHz_Complex_float
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/n-smart-system/Downloads/NavSAS_L1_5MHz_Complex_int16
    type: short
  states: {state: disabled}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: full_filename
    type: byte
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate*IQ_duration)
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"bladerf=c1ed7930fbad41d5bdc41cc810266af3"'
    bb_gain0: '0'
    bw0: samp_rate
    freq0: '1575420000'
    gain0: '0'
    gain_mode0: 'True'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    plotwaterfall: 'False'
    showports: 'True'
    type: complex
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: 10e6
    center_freq: f_L1
    dev_args: '"bladerf=c1ed7930fbad41d5bdc41cc810266af3"'
    gain: rx_gain
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    bandwidth: samp_rate
    center_freq: f_L1
    dev_args: hackrf=000cb3c0058435d
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_source_0
  id: soapy_source
  parameters:
    balance0: '0'
    center_freq0: f_L1
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'False'
    dev_args: '"bladerf=c1ed7930fbad41d5bdc41cc810266af3"'
    devname: bladerf
    overall_gain0: rx_gain
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [blocks_complex_to_interleaved_char_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_complex_to_interleaved_short_0, '0', blocks_file_sink_0_0, '0']
- [blocks_head_0, '0', blocks_complex_to_interleaved_char_0, '0']
- [osmosdr_source_0, '0', blocks_head_0, '0']
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']
- [soapy_bladerf_source_0, '0', blocks_complex_to_interleaved_char_0, '0']
- [soapy_bladerf_source_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [soapy_bladerf_source_0, '0', blocks_file_sink_0, '0']
- [soapy_bladerf_source_0, '0', qtgui_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_sink_x_0, '0']
- [soapy_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
