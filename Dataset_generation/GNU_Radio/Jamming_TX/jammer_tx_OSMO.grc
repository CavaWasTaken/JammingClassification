options:
  parameters:
    author: Arman Ebrahimi Mehr
    category: Custom
    copyright: NavSAS
    generate_options: qt_gui
    id: jammer_tx_OSMO
    output_language: python
    run_options: run
    title: jammer_tx_OSMO
  states: {}

blocks:
- name: bin_file
  id: variable_qtgui_chooser
  parameters:
    label: Interferent
    labels: '["Linear Narrow", "Linear Wide Fast",  "Tick", "Triangular Wave", "Triangular" ]'
    num_opts: '0'
    options: '[ "interference_bin/linear_narrow_10_20.bin", "interference_bin/linear_wide_fast_20.bin", "interference_bin/tick_3_20.bin", "interference_bin/triangular-wave_5_20.bin", "interference_bin/triangular_15_20.bin"]'
    type: string
    value: interference_bin/triangular-wave_5_20.bin
  states: {}
- name: fc_variate
  id: variable_qtgui_range
  parameters:
    label: fc_variate
    start: '-10e6'
    step: 1e6
    stop: +10e6
    value: '0'
  states: {}
- name: freq_L1
  id: variable
  parameters:
    value: 1.57542e9
  states: {}
- name: interference_fc
  id: variable
  parameters:
    value: freq_L1 + fc_variate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: tx_gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '50'
    value: '1'
  states: {}
- name: tx_gain_period
  id: variable
  parameters:
    value: '120000'
  states: {}
- name: blocks_file_source_0_1_0
  id: blocks_file_source
  parameters:
    alias: LAMPEDUSA
    file: bin_file
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("tick")
    period: tx_gain_period
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import pmt\nfrom gnuradio import gr\n\nclass blk(gr.basic_block):\n    def __init__(self, start_gain=0.0, step=1.0, max_gain=40.0):\n        gr.basic_block.__init__(\n            self,\n            name=\"tx_gain_controller\",\n            in_sig=None,\n            out_sig=None,\n        )\n\n        # Parameters\n        self.gain = float(start_gain)\n        self.step = float(step)\n        self.max_gain = float(max_gain)\n\n        # Message ports\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.set_msg_handler(pmt.intern(\"in\"), self.handle_msg)\n\n        self.message_port_register_out(pmt.intern(\"out\"))\n\n        # Send initial gain command at start (optional)\n        self._send_gain_cmd()\n\n    def _send_gain_cmd(self):\n        # Command dictionary for osmosdr: { 'gain': value }\n        cmd = pmt.to_pmt({'gain': float(self.gain)})\n        self.message_port_pub(pmt.intern(\"out\"), cmd)\n\n    def handle_msg(self, msg):\n        # Triggered every 2 minutes by Message Strobe\n        if self.gain < self.max_gain:\n            self.gain = min(self.gain + self.step, self.max_gain)\n            self._send_gain_cmd()\n            print(self.gain)\n        else:\n            # Already at max, do nothing (no more increase)\n            pass\n\n"
    max_gain: '40'
    start_gain: '0'
    step: '5'
  states: {}
- name: osmosdr_sink_0_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '0'
    freq0: interference_fc
    gain0: '16'
    if_gain0: tx_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: interference_fc
    fftsize: '1024'
    showrf: 'True'
    type: complex
  states: {}

connections:
- [blocks_file_source_0_1_0, '0', osmosdr_sink_0_0, '0']
- [blocks_file_source_0_1_0, '0', qtgui_sink_x_0, '0']
- [blocks_message_strobe_0, strobe, epy_block_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
