options:
  parameters:
    author: Arman Ebrahimi Mehr
    category: Custom
    copyright: NavSAS
    generate_options: qt_gui
    id: clean_tx_OSMO
    output_language: python
    run_options: run
    title: cleanjammer_tx_OSMO
  states: {}

blocks:
- name: fc_variate
  id: variable_qtgui_range
  parameters:
    label: fc_variate
    start: '-10e6'
    step: 1e6
    stop: +10e6
    value: '0'
  states: {}
- name: freq_L5
  id: variable
  parameters:
    value: 1.57542e9
  states: {}
- name: interference_fc
  id: variable
  parameters:
    value: freq_L5 + fc_variate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: tx_gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '50'
    value: '17'
  states: {}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    alias: LAMPEDUSA
    file: /home/arman-ebrahimi/Desktop/atlantis-ai/ML_Models/IQ_Dataset_samples/LINKS_L1_10Mhz_complex_int8_20250117_184014_CLEAN_0
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"bladerf=c1ed7930fbad41d5bdc41cc810266af3"'
    bb_gain0: '0'
    freq0: freq_L5
    gain0: '-5'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: osmosdr_sink_0_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '0'
    freq0: freq_L5
    gain0: '0'
    if_gain0: tx_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: interference_fc
    fftsize: '1024'
    showrf: 'True'
    type: complex
  states: {}

connections:
- [blocks_file_source_0_1, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_file_source_0_1, '0', osmosdr_sink_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', osmosdr_sink_0_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
