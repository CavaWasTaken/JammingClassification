options:
  parameters:
    author: Arman Ebrahimi Mehr
    copyright: 'NavSAS '
    generate_options: no_gui
    id: sdr_base
    output_language: python
    run_options: run
    title: Full sample of grabbing signals
  states: {}

blocks:
- name: buffer_size
  id: variable
  parameters:
    value: '500e-3'
  states: {}
- name: f_L1
  id: variable
  parameters:
    value: '1575420000'
  states: {}
- name: num_samples_buffer
  id: variable
  parameters:
    value: int(buffer_size*samp_rate)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: 2**7
    vector_output: 'False'
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: num_samples_buffer
    type: complex
  states: {state: disabled}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    type: byte
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"bladerf=0"'
    bb_gain0: '0'
    bw0: samp_rate
    freq0: f_L1
    gain0: '0'
    gain_mode0: 'True'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_interleaved_char_0, '0', blocks_vector_sink_x_0, '0']
- [blocks_head_0_0, '0', blocks_complex_to_interleaved_char_0, '0']
- [osmosdr_source_0, '0', blocks_complex_to_interleaved_char_0, '0']
- [osmosdr_source_0, '0', blocks_head_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
